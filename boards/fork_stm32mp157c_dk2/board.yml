## boards/fork_stm32mp157c_dk2/board.yml
```yaml
board:
  name: fork_stm32mp157c_dk2
  vendor: st
  socs:
    - name: stm32mp157cxx
```
